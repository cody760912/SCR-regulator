# Keil uVision project BS71B01M.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: BS71B01M +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c include: ..\drive;..\user;..\stm32f0;..\lib\inc;..\lib\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: startup_stm32f0xx.s
    ../stm32f0/: stm32f0xx_it.c system_stm32f0xx.c
  group user
    ./: main.c
  group drive
    ../drive/: systick.c Work.c SetGPIO.c SetNVIC.c SetTIM_BASE.c SetUsart.c Commu.c SetADC.c Dwin.c
  group lib
    ../lib/src/: stm32f0xx_dma.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_exti.c stm32f0xx_spi.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_adc.c stm32f0xx_flash.c
software components: CMSIS:CORE 5.0.1
